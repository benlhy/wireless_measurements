# Repository benlhy/wireless_measurements

File README.md:

# Introduction
The Simple Wireless Measurement (SWM) board is just that - it is a simple board designed to do wireless measurements for remote embedded circuits. It is capable of measuring current and voltage and transmitting it over Bluetooth.

You can retrieve the data with Python, NRF Connect App, or the Flutter app designed to display this data.

## Related Repos
* Software - Coming soon!
* Android/iOS - Coming soon!

# Contents
1. Mini - Contains the KiCAD files required for the mini board version
2. Stick - Contains the KiCAD files required for the standard board version
3. Arduino - Contains the KiCAD files required for the arduino implementation.

# How to use
1. Open the project in KiCAD. Export the gerber files and send it to the manufacturer of your choice. Some I've used before are JLCPCB and PCBway.
2. Assemble the board
3. Refer to the software repo to flash the software for the board you are using
4. Test the board using nRF Connect or the Python script or the Flutter App 

# Technology

The SWM board uses an EFM8LB12 microcontroller from Silabs to do the analog measurements. The EFM8 is capable of 14-bit ADC measurements with multiple inputs.

The SWM board uses the JDY-08 Bluetooth module because it provides a simple and transparent way to communicate readings over BLE: just connect and send the data over UART. It is also a very low-cost module (< $4). It can also be replaced with the JDY-23 which provides lower power draw, UART baud rate of 9600, and a lower cost of < $1 per module.

It is powered by the MCP16415 boost module which can take input ranges from 0.8V to 5.5V, which means that it can be powered by anything from a single AA rechargable to a 5V input from another board.

The total cost of the board comes up to roughly $15, which makes it cheap enough to throw permanently into a system to do wireless reporting of voltage and current. The board size is also small - about the size of two postage stamps placed side by side, which allows it to be embedded in other applications.

| Use case            | Description                                                                                            |
| ------------------- | ------------------------------------------------------------------------------------------------------ |
| Drones              | Measure the power draw of electronics on your drone over time                                          |
| Robotics            | Keep an eye on motors and batteries                                                                    |
| IoT                 | Monitor battries remotely                                                                              |
| Distributed systems | Monitor various test points in the system simultaneously to get a holistic picture of what is going on |
| Rocketry            | Monitor your wireless systems as you mount the rocket. Never wonder again if your system is dead.      |

## Specs

| Measured Current draw | Supplied Voltage | Status        | Version |
| --------------------- | ---------------- | --------      | ------- |
| 48 mA                 | 1.2V    | Fully On               | JDY-08  |
| 15 mA                 | 3.3V    | Fully On               | JDY-08  |
| 35 mA                 | 1.2V    | Fully On, Connected    | JDY-23  |
| 31 mA                 | 1.2V    | Fully On, Broadcasting | JDY-23  |
| 9 mA                  | 3.3V    | Fully On, Connected    | JDY-23  |
| 8 mA                  | 3.3V    | Fully On, Broadcasting | JDY-23  |

# Arduino Version

The Arduino Version is a simplified version of the full board but can be programmed directly in Arduino. It has a lower ADC resolution and a lower UART baud rate because it is using Software Serial.

## KiCad design mini/hardware/wireless_measurement_ard.kicad_pcb

Parts:
Battery1: Conn_01x02; PinSocket_1x02_P2.54mm_Vertical
C1, C4: 10uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C96446
C2, C3: 1uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C15849
C5: 4.7uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C19666
C6: 0.1uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C14663
C7, C8: 4.7uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C19666
C9: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C14663
D1: LED; LED_0603_1608Metric
J1: Conn_01x08; PinHeader_1x08_P2.54mm_Horizontal
J2: Tag-Connect; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
L1: 4.7uH; L_Bourns-SRN4018
R1: 1R; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2: 1R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 1k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R4: 866k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C101220
R5: 360k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C23146
R6: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C21190
R7, R8: 110k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C25805
SW1: SW_SPDT; SW_SPDT_CK-JS102011SAQN
U1: EFM8LB1; QFN-32-1EP_4x4mm_P0.4mm_EP2.9x2.9mm
U2: JDY-08; JDY-08_HandSoldering
U3: MCP16415; MSOP-10_3x3mm_P0.5mm
U4, U5: MAX40204; BGA-8_4x2_1.468x0.848mm
U6: Logo; icon

Connections:
+3V3: C1.1, C2.1, C5.1, C6.1, C8.1, C9.1, J1.7, R4.2, R6.1, R7.1, U1.2 (VIO), U1.3 (VDD), U2.1, U3.5, U4.A4 (VCC), U5.A4 (VCC)
A0: U1.18 (P1.7), U4.A3 (OUT)
A1: U1.19 (P1.6), U5.A3 (OUT)
A2: J1.5, U1.20 (P1.5)
A4: J1.6, U1.26 (P0.7)
A5: R7.2, R8.1, U1.21 (P1.4), U4.B2 (REF), U5.B2 (REF)
ARD_RX: U1.28 (P0.5), U2.19
ARD_TX: U1.29 (P0.4), U2.20
BATT: Battery1.1, J2.1, SW1.1 (A)
C1_IN: J1.1, R1.2, U4.A1 (RS+)
C1_OUT: J1.2, R1.1, U4.B1 (RS-)
C2CK: J2.3, R6.2, U1.4 (RSTb/C2CK)
C2D: J2.5, U1.5 (P3.7/C2D)
C2_IN: J1.3, R2.2, U5.A1 (RS+)
C2_OUT: J1.4, R2.1, U5.B1 (RS-)
GAIN: U1.16 (P2.1), U4.A2 (GAIN)
GAIN2: U1.15 (P2.2), U5.A2 (GAIN)
GND: Battery1.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.2, C9.2, J1.8, J2.6, R3.2, R5.1, R8.2, U1.33 (GND), U2.24, U3.7, U3.8, U4.B3 (GND), U5.B3 (GND)
LBO: U3.2
LED: D1.2 (A), U1.25 (P1.0)
MAX_SHDN: U1.17 (P2.0), U4.B4 (!SHDN)
MAX_SHDN2: U1.14 (P2.3), U5.B4 (!SHDN)
unnamed: C7.2, U1.1 (P0.0)
unnamed: D1.1 (K), R3.1
unnamed: L1.2, U3.6
PGT: U3.3
PWRC: U1.23 (P1.2), U2.22
STATUS: U1.22 (P1.3), U2.6
VFB: R4.1, R5.2, U3.4
VIN: C3.1, C4.1, L1.1, SW1.2 (B), U3.1, U3.9, U3.10

Notes on the sheet:
uA current sensing

Board: 4 copper layers, 30.0 x 23.0 mm, 29 parts (19 on the bottom side), 28 nets.

File mini/hardware/wireless_measurement_ard_bom.csv:

"Id";"Designator";"Package";"Quantity";"Designation";"Supplier and ref";
1;"U1";"QFN-32-1EP_4x4mm_P0.4mm_EP2.9x2.9mm";1;"EFM8LB1";;;
2;"U2";"JDY-08_HandSoldering";1;"JDY-08";;;
3;"U4";"SOT-23-6_Handsoldering";1;"MAX44284";;;
4;"R8";"R_0603_1608Metric_Pad0.98x0.95mm_HandSolder";1;"10k";;;
5;"R7";"R_0603_1608Metric_Pad0.98x0.95mm_HandSolder";1;"110k";;;
6;"L1";"L_Bourns-SRN4018";1;"4.7uH";;;
7;"U3";"MSOP-10_3x3mm_P0.5mm";1;"MCP16415";;;
8;"R6";"R_0603_1608Metric_Pad0.98x0.95mm_HandSolder";1;"1k";;;
9;"J2";"Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical";1;"Tag-Connect";;;
10;"SW1";"SW_SPDT_CK-JS102011SAQN";1;"SW_SPDT";;;
11;"C6";"C_0603_1608Metric_Pad1.05x0.95mm_HandSolder";1;"0.1uF";;;
12;"C5";"C_0603_1608Metric_Pad1.05x0.95mm_HandSolder";1;"4.7uF";;;
13;"R5";"R_0603_1608Metric_Pad1.05x0.95mm_HandSolder";1;"360k";;;
14;"R4";"R_0603_1608Metric_Pad1.05x0.95mm_HandSolder";1;"866k";;;
15;"J1";"PinHeader_1x08_P2.54mm_Horizontal";1;"Conn_01x08";;;
16;"C3,C2";"C_0603_1608Metric_Pad1.05x0.95mm_HandSolder";2;"1uF";;;
17;"Battery1";"PinSocket_1x02_P2.54mm_Vertical";1;"Conn_01x02";;;
18;"C4,C1";"C_0603_1608Metric_Pad1.05x0.95mm_HandSolder";2;"10uF";;;
19;"R1";"R_0805_2012Metric_Pad1.15x1.40mm_HandSolder";1;"1R";;;
20;"D1";"LED_0603_1608Metric";1;"LED";;;
21;"R3";"R_0603_1608Metric_Pad1.05x0.95mm_HandSolder";1;"1k";;;

## KiCad design wireless_measurement_ard.kicad_pcb

Parts:
Battery1: Conn_01x02; PinSocket_1x02_P2.54mm_Vertical
C1, C4: 10uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C2, C3: 1uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C5: 4.7uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C6: 0.1uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C7: 4.7uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: LED; LED_0603_1608Metric
EFM8_Prog1: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
H1, H2: MountingHole_Pad; MountingHole_2.2mm_M2_ISO7380_Pad
J1: Conn_01x08; PinHeader_1x08_P2.54mm_Horizontal
L1: 4.7uH; L_Bourns-SRN4018
R1: 5R3; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2: 1R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 1k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R4: 866k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R5: 360k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R6: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_SPDT; SW_SPDT_CK-JS102011SAQN
U1: EFM8LB1; QFN-32-1EP_4x4mm_P0.4mm_EP2.9x2.9mm
U2: JDY-08; JDY-08_HandSoldering
U3: MCP16415; MSOP-10_3x3mm_P0.5mm
U4: MAX44284; SOT-23-6_Handsoldering
U5: MAX9938; SOT-23-5_HandSoldering
U6: EFM8LB1x-QFP32; LQFP-32_7x7mm_P0.8mm

Connections:
+3V3: C1.1, C2.1, C5.1, C6.1, R4.2, R6.1, U1.2 (VIO), U1.3 (VDD), U2.1 (VCC), U3.5 (VOUT), U4.1, U4.6, U6.3 (VIO), U6.4 (VDD)
A0: U1.18 (P1.7), U4.5, U6.18 (P1.7)
A1: U1.19 (P1.6), U5.3 (OUT), U6.19 (P1.6)
A2: J1.5, U1.20 (P1.5), U6.20 (P1.5)
A3: J1.7, U1.21 (P1.4), U6.21 (P1.4)
ARD_RX: U1.28 (P0.5), U2.19 (P03/TXD), U6.28 (P0.5)
ARD_TX: U1.29 (P0.4), U2.20 (P02/RXD), U6.29 (P0.4)
BATT: Battery1.1, SW1.1 (A)
C1_IN: J1.2, R2.2, U4.3
C1_OUT: J1.1, R2.1, U4.4
C2CK: EFM8_Prog1.1, R6.2, U1.4 (RSTb/C2CK), U6.5 (RSTb/C2CK)
C2D: EFM8_Prog1.2, U1.5 (P3.7/C2D), U6.6 (P3.7/C2D)
C2_IN: J1.3, R1.1, U5.5 (RS+)
C2_OUT: J1.4, R1.2, U5.4 (RS-)
GND: Battery1.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, EFM8_Prog1.3, J1.6, J1.8, R3.2, R5.1, U1.33 (GND), U2.24 (GND), U3.7 (PGND), U3.8 (SGND), U4.2, U5.1 (GND), U5.2 (GND), U6.2 (GND)
LBO: U3.2 (LBO)
LED: D1.2 (A), U1.25 (P1.0), U6.25 (P1.0)
unnamed: D1.1 (K), R3.1
unnamed: L1.2, U3.6 (SW)
P0.0: C7.2, U1.1 (P0.0), U6.1 (P0.0)
P0.1: U1.32 (P0.1), U6.32 (P0.1)
P0.2: U1.31 (P0.2), U6.31 (P0.2)
P0.3: U1.30 (P0.3), U6.30 (P0.3)
P0.6: U1.27 (P0.6), U6.27 (P0.6)
P0.7: U1.26 (P0.7), U6.26 (P0.7)
P1.1: U1.24 (P1.1), U6.24 (P1.1)
P2.0: U1.17 (P2.0), U6.17 (P2.0)
P2.1: U1.16 (P2.1), U6.16 (P2.1)
P2.2: U1.15 (P2.2), U6.15 (P2.2)
P2.3: U1.14 (P2.3), U6.14 (P2.3)
P2.4: U1.13 (P2.4), U6.13 (P2.4)
P2.5: U1.12 (P2.5), U6.12 (P2.5)
P2.6: U1.11 (P2.6), U6.11 (P2.6)
P3.0: U1.10 (P3.0), U6.10 (P3.0)
P3.1: U1.9 (P3.1), U6.9 (P3.1)
P3.2: U1.8 (P3.2), U6.8 (P3.2)
P3.3: U1.7 (P3.3), U6.7 (P3.3)
PGT: U3.3 (PGT)
PWRC: U1.23 (P1.2), U2.22 (P00/PWRC), U6.23 (P1.2)
STATUS: U1.22 (P1.3), U2.6 (P16/LED), U6.22 (P1.3)
VFB: R4.1, R5.2, U3.4 (VFB)
VIN: C3.1, C4.1, L1.1, SW1.2 (B), U3.1 (ULVO), U3.9 (VIN), U3.10 (EN)

Notes on the sheet:
uA current sensing

Board: 2 copper layers, 70.0 x 21.2 mm, 27 parts (0 on the bottom side), 40 nets.

## KiCad design wireless_measurement.kicad_pcb

Board: 2 copper layers, 70.0 x 21.2 mm, 19 parts (0 on the bottom side), 18 nets.

Parts:
Battery1: Conn_01x02; PinSocket_1x02_P2.54mm_Vertical
C1, C4: 10uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C2, C3: 1uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C5: 4.7uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C6: 0.1uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
EFM8_Prog1: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J1: Conn_01x08; PinHeader_1x08_P2.54mm_Horizontal
L1: 4.7uH; L_Bourns-SRN4018
R1, R2: 5R3; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R4: 866k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R5: 360k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U2: JDY-08; JDY-08_HandSoldering
U3: MCP16415; MSOP-10_3x3mm_P0.5mm
U4, U5: MAX9938; SOT-23-5_HandSoldering
U6: EFM8LB1x-QFP32; LQFP-32_7x7mm_P0.8mm

Connections:
+3V3: C1.1, C2.1, C5.1, C6.1, R4.2, U2.1, U3.5, U6.3, U6.4
A0: U4.3, U6.18
A1: U5.3, U6.19
A2: J1.5, U6.20
A3: J1.7, U6.21
ARD_RX: U2.19, U6.28
ARD_TX: U2.20, U6.29
C1_IN: J1.1, R2.1, U4.5
C1_OUT: J1.2, R2.2, U4.4
C2CK: EFM8_Prog1.1, U6.5
C2D: EFM8_Prog1.2, U6.6
C2_IN: J1.3, R1.1, U5.5
C2_OUT: J1.4, R1.2, U5.4
GND: Battery1.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, EFM8_Prog1.3, J1.6, J1.8, R5.1, U2.24, U3.7, U3.8, U4.1, U4.2, U5.1, U5.2, U6.2
unnamed: L1.2, U3.6
STATUS: U2.6, U6.22
VFB: R4.1, R5.2, U3.4
VIN: Battery1.1, C3.1, C4.1, L1.1, U3.1, U3.9, U3.10

## Commit log

2021-07-31 init
2021-07-31 Added script to scan and connect to device
2021-07-31 removed old files and added software files
2021-07-31 removed fp-info-cache
2021-07-31 reorganized folder
2021-07-31 added efm8 project
2021-07-31 added code from old project
2021-07-31 Updated pins for efm8
2021-07-31 update clock
2021-08-02 update kicad to include holes
2021-08-25 update to fix VIO
2021-08-25 Halved the size of the board
2021-08-25 added readme
2021-08-25 added high-voltage measurement
2021-08-30 reorg folder and added readme for mini
2021-08-30 completed v1
2021-09-09 mini version
2021-09-10 changes for mini
2021-09-10 added new firmware
2021-09-10 updated board
2021-09-12 update to nano version
2021-09-16 Added new code for mini
2021-09-23 update files
2021-09-25 updated firmware code
2021-09-25 updated code with bugfixes
2021-09-25 updated footprint
2021-09-28 fixed powersupply
2021-09-28 fix added changes to pcb
2021-10-01 Rerouting to remove components below antenna
2021-10-01 label changes
2021-10-03 Added some markings
2021-10-03 added bidrectional current flow
2021-10-04 Added WSL footprint
2021-10-04 updated marking positions
2021-10-04 update footprint of silkscreen
2021-10-05 added links to 3d packages
2021-10-05 critical fix for cap connectd to power instead of gnd
2021-10-05 Added icon
2021-10-07 added logo
2021-10-07 removed unnecessary files
2021-10-25 removed software part
2021-10-26 update PCB
2021-10-28 Added capacitor
2021-11-07 added line to measure the half voltage for the MAX40204
